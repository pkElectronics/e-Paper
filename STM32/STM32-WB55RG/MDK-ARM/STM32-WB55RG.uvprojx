# Keil uVision project STM32-WB55RG.uvprojx, settings and files
target STM32-WB55RG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32-WB55RG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx
  c include: ../Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Drivers/CMSIS/Include; ..\User\Config; ..\User\e-Paper; ..\User\Examples; ..\User\GUI; ..\User\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User
    ../Src/: main.c gpio.c spi.c usart.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_gpio.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group e-Paper
    ../User/e-Paper/: EPD_1in54.c EPD_1in54_V2.c EPD_1in54b.c EPD_1in54c.c EPD_2in7.c EPD_2in7b.c EPD_2in9.c EPD_2in9bc.c EPD_2in9d.c EPD_2in13.c EPD_2in13_V2.c EPD_2in13bc.c EPD_2in13d.c EPD_4in2.c EPD_4in2bc.c EPD_5in83.c EPD_5in83bc.c EPD_7in5.c EPD_7in5bc.c
  group Config
    ../User/Config/: DEV_Config.c
  group GUI
    ../User/GUI/: GUI_Paint.c
  group Fonts
    ../User/Fonts/: font8.c font12.c font12CN.c font16.c font20.c font24.c font24CN.c
  group Examples
    ../User/Examples/: EPD_1in54_test.c EPD_1in54_V2_test.c EPD_1in54b_test.c EPD_1in54c_test.c EPD_2in7_test.c EPD_2in7b_test.c EPD_2in9_test.c EPD_2in9bc_test.c EPD_2in9d_test.c EPD_2in13_test.c EPD_2in13_V2_test.c EPD_2in13bc_test.c EPD_2in13d_test.c EPD_4in2_test.c EPD_4in2bc_test.c EPD_5in83_test.c EPD_5in83bc_test.c EPD_7in5_test.c EPD_7in5bc_test.c ImageData.c
software components: CMSIS:CORE 4.3.0
